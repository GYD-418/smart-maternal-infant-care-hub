# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\DHT11;..\HARDWARE\HX711;..\HARDWARE\Buzzer;..\HARDWARE\hot;..\HARDWARE\key;..\HARDWARE\motor;..\HARDWARE;..\HARDWARE\Serial
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DHT11/: DHT11.c DHT11.h DHT11_double.c DHT11_double.h
    ../HARDWARE/HX711/: HX711.c HX711.h
    ../HARDWARE/Buzzer/: Buzzer.c Buzzer.h
    ../HARDWARE/hot/: hot.c hot.h
    ../HARDWARE/key/: key.c key.h
    ../HARDWARE/motor/: motor.c motor.h
    ../HARDWARE/: pwm.c pwm.h
    ../HARDWARE/Serial/: Serial.c Serial.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c
    ../STM32F10x_FWLib/inc/: stm32f10x_exti.h
    ../../../32project/PWM驱动直流电机/Library/: stm32f10x_tim.c stm32f10x_tim.h
  group README
    ../: README.TXT
