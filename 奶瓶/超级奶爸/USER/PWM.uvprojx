# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c timer.h Emm_V5.h fifo.h main.h usart2.h usart4.h usart6.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ./: timer.c
    ./HARDWARE/: Emm_V5.c
    ../HARDWARE/: fifo.c usart2.c usart4.c usart6.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c
    D:/stm32所有东西/【正点原子】探索者STM32F407开发板资料 资料盘(A盘)/【正点原子】探索者STM32F407开发板资料 资料盘(A盘)/4，程序源码/2，标准例程-库函数版本/实验5 外部中断实验/FWLIB/src/: stm32f4xx_exti.c
  group README
    ../: readme.txt
